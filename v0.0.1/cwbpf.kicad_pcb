# Repository xcd0/cwbpf

File readme.md:

# モールス信号用可変BPFオーディオフィルター 仕様書

## v0.0.3

音声対応する。

v0.0.2 で現実的な範囲での適切なサンプリングレートを把握し、  
リアルタイム音声処理を実装する。  
処理の軽い特徴量抽出を実装して、音声を聞きやすくする。  

## v0.0.2

ADCとDACを強化する。

目的に対しオーバースペックだが、秋月電子で手に入るPCM1808とPCM5102Aを使用する。
- PCM1808
    - 24bit, ~192kHz, 98dB, I2S
    - https://akizukidenshi.com/catalog/g/g112988/
    - http://www.easyaudiokit.com/bekkan3/PCM1808/PCM1808.html
- PCM5102A
    - 32bit, ~384kHz, 112dB, I2S
    - https://akizukidenshi.com/catalog/g/g111836/
    - http://www.easyaudiokit.com/bekkan/PCM5102/PCM5102.html
を使用する。

ADCとDACを正しく扱えるようになった前提で、
どこまでサンプリングレートを上げて、picoが処理落ちしないかを確認する。

将来的には、raspberry pi picoの処理能力の余力次第で、下記を目標にしていく。
- アナログLPFの回路を減らして、サンプリングレートを上げ、デジタル処理側でのフィルタ処理を増やしたい。(アナログ回路の実装面積削減)
- 更に処理能力に余力があれば、人の声を対象に、MFCCとかを使用して特徴量抽出、再変換して、声を聴きやすくする機能を実装したい。(CW以外の音声処理)

### PCM1808とPCM5102A解説 (Raspberry Pi Pico用)

下記は Claude Sonnet 4 の解説。

> # PCM1808とPCM5102A解説 (Raspberry Pi Pico用)
> 
> ## PCM1808 (24bit ADC)
> 
> ### 概要
> - **用途**: アナログ音声信号 → デジタル信号変換 (録音・収音)
> - **分解能**: 24bit
> - **サンプリングレート**: 8kHz～192kHz
> - **SNR**: 98dB
> - **インターフェース**: I2S出力
> 
> ### 主要ピン機能
> - **VINL+/VINL-**: 左チャンネル差動入力
> - **VINR+/VINR-**: 右チャンネル差動入力  
> - **DOUT**: デジタル音声データ出力
> - **BCKO**: ビットクロック出力
> - **LROUT**: L/Rチャンネル選択クロック出力
> - **MD0/MD1**: サンプリングレート設定
> - **FMT0/FMT1**: 出力フォーマット設定
> 
> ## PCM5102A (32bit DAC)
> 
> ### 概要
> - **用途**: デジタル信号 → アナログ音声信号変換 (音声出力)
> - **分解能**: 32bit
> - **サンプリングレート**: 最大384kHz
> - **SNR**: 112dB
> - **インターフェース**: I2S入力
> 
> ### 主要ピン機能
> - **DIN**: デジタル音声データ入力
> - **BCK**: ビットクロック入力
> - **LRCK**: L/Rチャンネル選択クロック入力
> - **OUTL/OUTR**: アナログ音声出力
> - **XSMT**: ミュート制御
> - **FMT**: オーディオフォーマット選択
> 
> ## Raspberry Pi Pico接続回路図
> 
> ### PCM1808 (ADC) 接続
> ```
> Raspberry Pi Pico              PCM1808 ADC
>                               
> GPIO 18 (I2S BCK) <----------- BCKO (Bit Clock Output)
> GPIO 19 (I2S WS)  <----------- LROUT (Word Select Output)  
> GPIO 20 (I2S DIN) <----------- DOUT (Data Output)
> 3V3 OUT ---------------------> VDD (3.3V Digital)
> 5V OUT (VBUS) --------------> VCC (5V Analog)
> GND ---------------------> DGND/AGND
> 
> 設定ピン:
> MD1 ---------> GND (単一速度モード)
> MD0 ---------> VDD (8-50kHz)
> FMT1 --------> GND (I2Sフォーマット)
> FMT0 --------> GND  
> OSR1 --------> GND
> OSR0 --------> VDD
> HPF ---------> VDD (ハイパスフィルタ有効)
> SCKI --------> GND (内蔵クロック使用)
> 
> アナログ入力:
> Audio Input L --[100nF]--- VINL+
>                     |
>                  [47kΩ]
>                     |
>                   AGND ---- VINL-
> 
> Audio Input R --[100nF]--- VINR+
>                     |
>                  [47kΩ]
>                     |
>                   AGND ---- VINR-
> ```
> 
> ### PCM5102A (DAC) 接続
> ```
> Raspberry Pi Pico              PCM5102A DAC
>                               
> GPIO 21 (I2S BCK) -----------> BCK (Bit Clock)
> GPIO 22 (I2S WS)  -----------> LRCK (Word Select)  
> GPIO 23 (I2S DIN) -----------> DIN (Data Input)
> 3V3 OUT ---------------------> VDD (3.3V)
> GND ---------------------> GND
> 
> 設定ピン:
> SCK ---------> GND (外部クロック使用しない)
> XSMT --------> VDD (ミュート解除)
> FMT ---------> GND (I2Sフォーマット)
> DEMP --------> GND (デエンファシス無効)
> FLT ---------> GND (ノーマルレイテンシ)
> AVDD --------> VDD または 5V (より良い音質)
> 
> アナログ出力:
> OUTL --------> Left Audio Output
> OUTR --------> Right Audio Output
> ```
> 
> ### 完全システム接続図
> ```
>                     Raspberry Pi Pico
>     Audio Input     ┌─────────────────┐     Audio Output
>          │          │                 │          │
>     ┌────▼────┐     │  GPIO 18 ←──────┼─┐    ┌───▼────┐
>     │ PCM1808 │     │  GPIO 19 ←──────┼─┼─┐  │PCM5102A│
>     │   ADC   │     │  GPIO 20 ←──────┼─┼─┼─┐│  DAC   │
>     │         │     │                 │ │ │ ││        │
>     │ BCKO ───┼─────┼─→ GPIO 18       │ │ │ ││        │
>     │ LROUT───┼─────┼─→ GPIO 19       │ │ │ ││        │
>     │ DOUT ───┼─────┼─→ GPIO 20       │ │ │ ││        │
>     │         │     │                 │ │ │ ││        │
>     │         │     │  GPIO 21 ───────┼─┼─┼─┼┼─→ BCK  │
>     │         │     │  GPIO 22 ───────┼─┼─┼─┼┼─→ LRCK │
>     │         │     │  GPIO 23 ───────┼─┼─┼─┼┼─→ DIN  │
>     │         │     │                 │ │ │ ││        │
>     │ VDD ────┼─────┼── 3V3           │ │ │ ││── VDD  │
>     │ VCC ────┼─────┼── 5V            │ │ │ ││        │
>     │ GND ────┼─────┼── GND ──────────┼─┼─┼─┼┼── GND  │
>     └─────────┘     └─────────────────┘ │ │ │└────────┘
>                                         │ │ │
>                                         │ │ └─ GPIO 23
>                                         │ └─── GPIO 22  
>                                         └───── GPIO 21
> ```
> 
> ## ピン割り当て表
> 
> | 用途 | PCM1808 | Pico GPIO | PCM5102A |
> |------|---------|-----------|----------|
> | BCK | BCKO (出力) | 18 | BCK (入力) |
> | WS/LRCK | LROUT (出力) | 19 | LRCK (入力) |
> | データ | DOUT (出力) | 20 | - |
> | データ | - | 21 | BCK (入力) |
> | データ | - | 22 | LRCK (入力) |
> | データ | - | 23 | DIN (入力) |
> 
> ## 実装上の注意点
> 
> ### 電源設計
> - **PCM1808**: VDD=3.3V (デジタル), VCC=5V (アナログ、音質向上)
> - **PCM5102A**: VDD=3.3V, AVDD=3.3Vまたは5V (音質向上)
> - 各電源に100nF + 10µFバイパスコンデンサ配置
> 
> ### クロック設計
> - PCM1808がマスター (クロック出力)
> - PCM5102AがスレーブPIOで同期
> - または独立したI2Sポートで個別制御
> 
> ### グランド設計
> - デジタルグランド (DGND) とアナロググランド (AGND) を1点で接続
> - 適切なグランドプレーン配置でノイズ対策
> 
> この構成により、Raspberry Pi Picoで高品質な音声録音・再生システムを構築できます。

## KiCad design v0.0.1/cwbpf.kicad_pcb

File v0.0.1/readme.md:

## モールス信号用可変BPFオーディオフィルター 仕様書 v0.0.1

### 1. 設計目的

* 用途: モールス信号(400-2000Hz)の聞き取り改善
* 処理: リアルタイムDSP可変バンドパスフィルタ
* 遅延: <10ms (要求 <200ms)
* 音質: 高S/N比、低歪み

### 2. システム構成

* MCU: Raspberry Pi Pico (RP2040)
* 処理: モノラル、リアルタイム
* 電源: USB給電またはVSYS 5V入力
* 特徴: 4次Butterworth多重帰還型アンチエイリアシングLPF

### 3. 入出力仕様

#### 3.1 入力部

* コネクタ: 3.5mmモノラルジャック (Tip=信号, Sleeve=GND)
* 入力インピーダンス: 10kΩ
* 最大入力振幅: ±1V (1.65Vバイアス中心)
* 周波数帯域: 20Hz-20kHz
* プリアンプ: 可変ゲイン 1-11倍 (RV1)

#### 3.2 出力部

* コネクタ: 3.5mmモノラルジャック
* 出力インピーダンス: <100Ω
* 最大出力振幅: ±1V (1.65Vバイアス中心)
* 負荷: 32Ω以上推奨
* 音量調整: 可変抵抗 RV4 10kΩ

#### 3.3 制御部

* 可変抵抗: 3本 + 入力ゲイン用 1本

  * 入力ゲイン (RV1) 1-11倍
  * BPF下限周波数 (RV3, GPIO28)
  * BPF上限周波数 (RV2, GPIO27)
  * 出力音量 (RV4)

### 4. デジタル処理仕様

#### 4.1 ADC仕様

* 分解能: 12bit (0-4095)
* サンプリング周波数: 16kHz
* 入力方式: 内蔵ADC + DMA + タイマ割込み
* 基準電圧: 1.65V 中点 (AGND基準)
* 入力チャネル: GPIO26 (ADC0)

#### 4.2 DSP処理

* フィルタ構成: 双2次IIR ×2段 → 4次可変BPF
* 特性: Butterworth特性
* 制御周波数範囲: 下限400-上限2000Hz
* バッファサイズ: 32サンプル (2ms)
* 全処理遅延: 約5ms

#### 4.3 DAC仕様

* IC: MCP4921 (12bit SPI DAC)
* 分解能: 12bit (0-4095)
* 出力電圧範囲: 0-3.3V (1.65V中心)
* 更新レート: 16kHz 同期
* SPI信号: CS=GPIO1, SCK=GPIO2, SDI=GPIO3

### 5. アナログ回路仕様

#### 5.1 プリアンプ部

* IC: NJM4580 (U1C)
* 構成: 非反転増幅器
* ゲイン: 1-11倍 (RV1)
* 帯域幅: DC-100kHz
* S/N比: >65dB
* バイアス: 1.65V (単電源動作)

#### 5.2 アンチエイリアシングLPF（4次Butterworth多重帰還型）

* IC: NJM4580 (U2A, U2B)
* 構成: 多重帰還型第2次フィルタ ×2段
* カットオフ周波数: 3.0kHz (@-3dB)
* 8kHzでの減衰量: 約-34.1dB
* Q値: 0.707 (Butterworth)
* 部品定数例:

  * 1段目: R5=11kΩ, R6=11kΩ, C3=100nF, C4=100nF
  * 2段目: R7=11kΩ, R9=11kΩ, C6=100nF, C7=100nF

#### 5.3 出力アンプ部

* IC: NJM4580 (U1B)
* 構成: 非反転バッファ
* ゲイン: 1倍
* 出力インピーダンス: <100Ω
* バイアス: 1.65V

#### 5.4 バイアス電圧生成

* 分圧抵抗: R11=10kΩ, R12=10kΩ
* 出力: 1.65V
* AGND: アナログ専用GND (Raspberry Pi Pico pin33)

#### 5.5 電源・デカップリング

* 電源電圧: 3.3V (Raspberry Pi Pico 3V3)
* デカップリング: 各IC Vcc-AGND 間に 100nF

### 6. 性能仕様

| 周波数 | 通過特性      | 用途・効果               |
| ------ | ------------- | ------------             |
| 400Hz  | BPF下限       | モールス信号下限周波数   |
| 800Hz  | BPF中心       | 信号中心周波数           |
| 1200Hz | BPF上限       | モールス信号上限周波数   |
| 3.0kHz | -3dB (LPF fc) | アンチエイリアシング開始 |
| 8kHz   | -34.1dB       | エイリアシング抑制       |
| 12kHz  | -46dB         | 高調波抑制               |

* S/N比: >70dB (AGND効果含む)
* THD: <0.5% (1kHz, 0.5Vrms)
* 総遅延: <10ms
* 消費電流: <100mA (Pico込み)
* 動作温度: 0-50℃

### 7. 部品構成・概算コスト

* 半導体: Pi-Pico, NJM4580×2, MCP4921
* 受動部品: 抵抗, コンデンサ, 可変抵抗
* 概算総コスト: 約3,000円

部品表

| リファレンス                         | 数量   | 値               | 説明                                                  | 単価    | 小計     |
| -------------                        | ------ | ----             | ----                                                  | ------  | ------   |
| A1                                   | 1      | RaspberryPi_Pico | Raspberry Pi Pico マイコンボード                      | \770    | \770     |
| C1,C2,C3,C8                          | 4      | 100n             | メタライズドポリエステルフィルムコンデンサ 0.1μF 100V | \20     | \80      |
| C4,C6                                | 2      | 10n              | メタライズドポリエステルフィルムコンデンサ 10nF 100V  | \20     | \40      |
| C5,C7                                | 2      | 1.5n             | フィルムコンデンサ 1500pF 50V (ルビコンF2D)           | \10     | \20      |
| C9                                   | 1      | 10u              | オーディオ用電解コンデンサ 10μF 25V                   | \20     | \20      |
| C10                                  | 1      | 100u             | オーディオ用電解コンデンサ 100μF 25V 85℃ (ニチコンFG) | \20     | \20      |
| J1,J2                                | 2      | AudioJack4       | 4極オーディオジャック                                 | \100    | \200     |
| R1,R2,R3,R4,R5,R7,R8,R10,R11,R12,R13 | 11     | 10k              | 小型金属皮膜抵抗 10kΩ 1/4W                            | \2.5    | \27.5    |
| R6                                   | 1      | 18k              | 小型金属皮膜抵抗 18kΩ 1/4W                            | \2.5    | \2.5     |
| R9                                   | 1      | 47k              | 小型金属皮膜抵抗 47kΩ 1/4W                            | \2.5    | \2.5     |
| R14,R15                              | 2      | 100              | 小型金属皮膜抵抗 100Ω 1/4W                            | \2.5    | \5       |
| RV1,RV4                              | 2      | 10k              | 基板用薄型ボリューム 10kΩB                            | \60     | \240     |
| RV2,RV3                              | 2      | 10k              | 基板用薄型ボリューム 10kΩA                            | \60     | \240     |
| U1,U2                                | 2      | NJM4580          | オーディオ用デュアルオペアンプ                        | \120    | \240     |
| U3                                   | 1      | MCP4921          | 12bit SPI DAコンバータ                                | \330    | \330     |

* OPアンプ はフィルタ設計で重要なGBWマージンを確保するため、GBW ? 9 MHz の NJM4580 を採用。部品許容差が特性に影響しやすいため抵抗は±1 %、コンデンサは温度係数の低いMLCCを推奨します。
* 可変抵抗 はBカーブ（対数）を使用し、モールス信号の聞き取りに適した可変幅を実現。RV1はプリアンプゲイン、RV2/RV3はLPF段の上下限調整、RV4は最終出力音量に割り当てます。
* コンデンサ はフィルタ用とデカップリング用を兼用し、計7個の0.1 μFを配置。デジタル部とアナログ部でAGNDを分離し、C9でPi Pico AGNDへデカップリングします。
* 電解コンデンサ は出力カップリング（C10）とDCバイアス安定化（C11）に使用。音質への影響を抑えるため低ESR品を選定してください。
* オーディオジャック は基板実装型でTip/Sleeveの配線を明確に。負荷32 Ω以上を想定し、インピーダンスマッチングに優れた部品を選びます。
* マイコン はRaspberry Pi Picoを使用し、ADC/DAC制御・DSP処理・SPI制御を一台で担います。

### 8. 実装概要

* 試作: ブレッドボード段階的テスト
* 最終実装: ユニバーサル基板, AGND専用レイアウト
* 機能: ADC DMA + タイマ割込み, DSP, SPI DAC, 可変抵抗読み込み

Parts:
A1: RaspberryPi_Pico; RaspberryPi_Pico_slim
C1, C2, C3, C8: 100n; C_Disc_D7.5mm_W2.5mm_P5.00mm
C4, C6: 10n; C_Disc_D7.0mm_W2.5mm_P5.00mm
C5, C7: 1.5n; C_Disc_D7.0mm_W2.5mm_P5.00mm
C9: 10u; CP_Radial_D5.0mm_P2.00mm
C10: 100u; CP_Radial_D8.0mm_P3.50mm
J1, J2: AudioJack4; Jack_3.5mm_PJ320E_Horizontal
R1, R2, R3, R4, R5, R7, R8, R10, R11, R12, R13: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R6: 18k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R9: 47k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R14, R15: 100; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
RV1, RV2, RV3, RV4: 10k; 基板取付用ボリューム つまみ付き 薄型 10kΩ 2連
U1, U2: NJM4580; SIP-8_19x3mm_P2.54mm
U3: MCP4921; DIP-8_W7.62mm

Connections:
1.65V: R3.2, R10.1, R11.2, U1.2 (-), U1.6 (-)
3.3V: A1.36 (3V3), C3.2, C8.1, R10.2, RV2.5 (R1_3), RV3.1 (R12_1), U1.8 (V+), U2.8 (V+), U3.1 (Vdd), U3.6 (Vref)
AGND: A1.33 (AGND), C2.2, C3.1, C4.2, C6.2, C8.2, J1.S, J2.S, R11.1, RV1.1 (R12_1), RV2.1 (R12_1), RV3.5 (R1_3), RV4.5 (R1_3), U1.4 (V-), U2.3 (+), U2.4 (V-), U2.5 (+)
GND: A1.3 (GND), A1.8 (GND), A1.13 (GND), A1.18 (GND), A1.23 (GND), A1.28 (GND), A1.38 (GND), U3.5 (~LDAC), U3.7 (Vss)
GPIO_1: A1.2 (GPIO1), U3.2 (~CS)
GPIO_2: A1.4 (GPIO2), U3.3 (SCK)
GPIO_3: A1.5 (GPIO3), U3.4 (SDI)
GPIO_26: A1.31 (GPIO26_ADC0), C7.2, R9.2, U2.7
GPIO_27: A1.32 (GPIO27_ADC1), RV2.2 (R1_2)
GPIO_28: A1.34 (GPIO28_ADC2), RV3.2 (R1_2)
unnamed: C1.1, R1.2
unnamed: C1.2, J1.T
unnamed: C4.1, R4.1, R5.1, R6.1
unnamed: C6.1, R7.1, R8.1, R9.1
unnamed: C9.1, R12.2
unnamed: C10.1, R14.2, R15.2
unnamed: J2.R1, R14.1
unnamed: J2.T, R15.1
unnamed: R2.1, RV1.2 (R1_2), U1.3 (+)
unnamed: R1.1, RV1.5 (R1_3)
unnamed: C10.2, RV4.2 (R1_2)
unnamed: R12.1, R13.2, U1.5 (+)
unnamed: C5.1, R6.2, U2.2 (-)
unnamed: C7.1, R8.2, U2.6 (-)
output_LPF1: C5.2, R5.2, R7.2, U2.1
output_amp: R13.1, RV4.1 (R12_1), U1.7
output_dac: C9.2, U3.8 (Vout)
output_preamp: C2.1, R2.2, R3.1, R4.2, U1.1

Notes on the sheet:
基板取付用ボリューム つまみ付き 薄型 10kΩB 2連
上限周波数調整ボリューム
下限周波数調整ボリューム
DC遮断
デカップリング
アンチエイリアシングフィルタ (4次Butterworth多重帰還型LPF) fc=3kHz 8kHzで-34.1dB
プリアンプ
バイアス電圧生成
基板取付用ボリューム つまみ付き 薄型 10kΩA 2連
出力アンプ
バイアス電圧重畳回路
入力ゲイン調整
出力DAC

Board: 2 copper layers, 115.0 x 36.0 mm, 35 parts (0 on the bottom side), 28 nets.

## Commit log

2025-06-17 v0.0.1
